## boards/shields/encodetest/Kconfig.defconfig
```kconfig
if SHIELD_ENCODETEST

config ZMK_KEYBOARD_NAME
    default "encodetest"

endif # SHIELD_ENCODETEST
```
